FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
SPLASH_IMAGES_rpi = "file://psplash-ann-img.h;outsuffix=raspberrypi"

